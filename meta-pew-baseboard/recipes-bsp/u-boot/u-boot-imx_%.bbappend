# Copyright 2022-2023 Panasonic Corporation

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-u-boot-imx8mn-pew.patch \
"

